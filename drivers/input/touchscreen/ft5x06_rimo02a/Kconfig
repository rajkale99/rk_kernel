## drivers/input/touchscreen/ft5x06_rimo02a/Kconfig
```kconfig
config TOUCHSCREEN_FT5X06_RIMO02A
	tristate "FT5X06 touchpanel driver for rimo02a"
	depends on CONFIG_INPUT_TOUCHSCREEN
	default n
```
